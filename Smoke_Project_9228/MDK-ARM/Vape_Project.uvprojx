# Keil uVision project Vape_Project.uvprojx, settings and files
target Vape_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Vape_Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F401xE,__FPU_PRESENT=1,__FPU_USED=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c misc: --C99 --locale=english
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\APP;..\Display_driver;..\Flash;..\main;..\USB;..\APP\Interface;..\APP\Out_Control;..\APP\RTC;..\APP\Touch;..\APP\TFT_Init;..\STemWinLibrary532;..\STemWinLibrary532\Config;..\STemWinLibrary532\Documentation;..\STemWinLibrary532\inc;..\STemWinLibrary532\Lib;..\STemWinLibrary532\OS;..\STemWinLibrary532\Simulation;..\STemWinLibrary532\Software\JPEG2MovieScripts;..\APP\Malloc;..\STemWinLibrary532\emwin_png\V532\png;..\STemWinLibrary532\emwin_png\V544\png;..\STemWinLibrary532\Font;..\Drivers\CMSIS\Include;..\APP\Vibrate;..\APP\KEY_LED;..\STemWinLibrary532\Font2
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20001800 size 0x16800
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ramfunc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_spi.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_dma.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_ll_adc.c stm32f4xx_hal_adc.c stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c stm32f4xx_ll_tim.c stm32f4xx_ll_usb.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_ll_dma.c stm32f4xx_ll_rcc.c stm32f4xx_ll_crc.c stm32f4xx_ll_rtc.c
    ../Drivers/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../Drivers/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
  group Application/User
    ../Src/: tim.c main.c stm32f4xx_hal_msp.c usbd_desc.c gpio.c adc.c usbd_custom_hid_if.c spi.c stm32f4xx_it.c usb_device.c usbd_conf.c crc.c rtc.c dma.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group APP
    ../main/: APP_Delay.c APP_PWM_int.c ADC_Module.c APP_Compare.c APP_Atomizer.c APP_ChargingBAT.c APP_Custom.c APP_FLASH.c APP_KEY.c APP_OutputControl.c APP_Sleeping.c sqrt_16.c Statistics Port number.c
    ../APP/RTC/: APP_RTC.c
  group 界面显示
    ../APP/Interface/: WM_Disp.c Main interface.c Alarm_interface.c public.c System_off_interface.c One_Power_interface.c Atomizer_inquiry_interface.c Main_menu_interface.c TCR_adjust_Interface.c Custom_curve_adjustment_interface.c Lock_Resis_Interface.c System_settings_interface.c Screensaver_interface.c RTC_Set_interface.c Firmware_Tim_interface.c Battery_charging_interface.c VT_MODE_Set_interface.c DIY_menu_interface.c
  group 输出控制
    ../APP/Out_Control/: Bypass_MODE_Control.c CurveWatt_MODE_Control.c Tempe_MODE_Control.c Voltage_MODE_Control.c Watt_MODE_Control.c CurveCCT_Mode_control.c CurveCCV_Mode_control.c SPP_MODE_Control.c
  group USB升级
    ../USB/: APP_USB.c Program_Upgrade_Status.c
  group 电池电压校准
    ../APP/Interface/: Batt_JZ_interface.c
  group 外部FLASH
    ../Flash/: Flahs_Data.c Flahs_Driver.c Flahs_Data.h
  group 屏幕底层驱动
    ../APP/TFT_Init/: TFT_Init.c TFT_Drive.c Brightness_AUTO.c
  group Emwin
    ../STemWinLibrary532/Lib/: STemWin532_CM4_Keil_ot.lib
    ../STemWinLibrary532/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../STemWinLibrary532/OS/: GUI_X.c
    ../STemWinLibrary532/: GUI_image_FLASH.c
  group 字库管理
    ../STemWinLibrary532/Font/: GUI_XBF_Font.c
  group 震动马达
    ../APP/Vibrate/: Vibrate.c
  group 按键灯驱动
    ../APP/KEY_LED/: KEY_LED.c
  group Fount
    ../STemWinLibrary532/Font/: Century45Gothic10_808.c Gill37Sans_MT9_264.c Gill18Sans_MT4_632.c Accidental_Presidency140.c
    ../Emwin_使用图片/字体/: Arial17.c Arial22.c Arial27.c Arial32.c Arial41.c Arial47.c Arial60.c Arial82.c Raavi18.c Raavi22.c Raavi33_16.c Raavi38B_19.c Raavi64B_28.c
    ../STemWinLibrary532/Font2/: Raavi49B_22.c
software components: CMSIS:CORE 4.3.0
